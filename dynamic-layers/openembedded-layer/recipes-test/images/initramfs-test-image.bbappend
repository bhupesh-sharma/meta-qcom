PACKAGE_INSTALL += " \
    cryptsetup \
    libkcapi \
    iozone3 \
    lshw \
    lshw \
    devmem2 \
"
